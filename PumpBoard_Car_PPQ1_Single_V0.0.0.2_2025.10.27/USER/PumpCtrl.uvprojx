# Keil uVision project PumpCtrl.uvprojx, settings and files
target PPQ_Ctrl (6240000::V6.24::ARMCLANG)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf.exe --bin -o "PumpCtrl_V0.1.0.4.bin" "#L"
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,STM32F407xx,USE_STDPERIPH_DRIVER,USE_USB_FS
  c include: ..\CORE;..\Function;..\FWLIB\inc;..\HardWare_Init\Inc;..\USB\STM32_USB_Device_Library\Class\CDC\Inc;..\USB\STM32_USB_Device_Library\Core\Inc;..\USB\USB_APP;..\USB\USB_HAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash_md5.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HardWare_Init
    ../HardWare_Init/Src/: Hw_SPI.c Hw_ADC.c Hw_GPIO.c Hw_TIM.c AD7689.c Hw_CAN.c
  group Function
    ../Function/: algorithm.c analog_input.c application.c flash.c stm32f4xx_it.c Task.c CheckTable.c limit.c Diagnose.c can_protocol.c
  group LIB
    ../LIB/: Deadzone_Current.lib PID_AREA.lib
